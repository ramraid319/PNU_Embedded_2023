# IAR project term.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: Libraries\CMSIS\DeviceSupport; Libraries\CMSIS\DeviceSupport\Startup; Libraries\STM32F10x_StdPeriph_Driver_v3.5\inc; Libraries\STM32F10x_StdPeriph_Driver_v3.5\src; Libraries\LCD; user; user\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: term.bin
  ILINK.IlinkOutputFile: term.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CoreSupport
    CoreSupport/: core_cm3.c core_cm3.h
  group Debug/BrowseInfo
    Debug/BrowseInfo/: .ninja_deps .ninja_log build.ninja term.pbd term.pbd.browse term.pbw
  group Debug/BrowseInfo/CoreSupport_9349358829246811252.dir
    Debug/BrowseInfo/CoreSupport_9349358829246811252.dir/: core_cm3.pbi core_cm3.xcl
  group Libraries/CMSIS/DeviceSupport
    Libraries/CMSIS/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries/CMSIS/DeviceSupport/Startup
    Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
  group Libraries/LCD
    Libraries/LCD/: font.h lcd.c lcd.h touch.c touch.h
  group Libraries/STM32F10x_StdPeriph_Driver_v3.5/inc
    Libraries/STM32F10x_StdPeriph_Driver_v3.5/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries/STM32F10x_StdPeriph_Driver_v3.5/src
    Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group settings
    settings/: term.Debug.cspy.bat term.Debug.cspy.ps1 term.Debug.driver.xcl term.Debug.general.xcl term.dnx
  group user
    user/: bluetooth.c main.c sensor.c servo.c stm32f10x_it.c
  group user/inc
    user/inc/: bluetooth.h common.h sensor.h servo.h stm32f10x_conf.h stm32f10x_it.h
